# IAR project xncp-led_3.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: SERIAL_UART_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM3588; PHY_EM3XX; CONFIGURATION_HEADER="ncp-configuration.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"; BOARD_DEV0680UART; BOARD_HEADER="ncp-board.h"; USE_SIMEE2; EZSP_UART; NO_USB; EMLIB_USER_CONFIG; EMBER_AF_NCP; EMBER_STACK_ZIGBEE; EMBER_AF_API_NEIGHBOR_HEADER="stack/include/stack-info.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_BUFFER; EMBER_SERIAL1_TX_QUEUE_SIZE=2; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL1_RTSCTS; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=64; EMBER_SERIAL0_RX_QUEUE_SIZE=64; APPLICATION_TOKEN_HEADER="ncp-token.h"; APPLICATION_MFG_TOKEN_HEADER="ncp-mfg-token.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\protocol\zigbee\app\ncp\..\..; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\protocol\zigbee\app\ncp\..\..\stack; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\protocol\zigbee\app\ncp\..\util; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\plugin; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\..\..\radio\rail_lib\plugin; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\..; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\..\..\CMSIS\Include; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\..\..\Device\SiliconLabs\em358x\Include; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\micro\cortexm3\em35x\board; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\radio\rail_lib\plugin\coexistence\hal\em3xx; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\segger\systemview\Config; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\segger\systemview\SEGGER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: SERIAL_UART_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM3588; PHY_EM3XX; CONFIGURATION_HEADER="ncp-configuration.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; BOARD_DEV0680UART; BOARD_HEADER="ncp-board.h"; USE_SIMEE2; EZSP_UART; NO_USB; EMLIB_USER_CONFIG; EMBER_AF_NCP; EMBER_STACK_ZIGBEE; EMBER_AF_API_NEIGHBOR_HEADER="stack/include/stack-info.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_BUFFER; EMBER_SERIAL1_TX_QUEUE_SIZE=2; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL1_RTSCTS; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=64; EMBER_SERIAL0_RX_QUEUE_SIZE=64; APPLICATION_TOKEN_HEADER="ncp-token.h"; APPLICATION_MFG_TOKEN_HEADER="ncp-mfg-token.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\protocol\zigbee\app\ncp\..\..; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\protocol\zigbee\app\ncp\..\..\stack; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\protocol\zigbee\app\ncp\..\util; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\plugin; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\..; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\..\..\CMSIS\Include; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\..\..\Device\SiliconLabs\em358x\Include; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\micro\cortexm3\em35x\board; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\radio\rail_lib\plugin\coexistence\hal\em3xx; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\segger\systemview\Config; ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\segger\systemview\SEGGER
  OBJCOPY.OOCOutputFile: xncp-led_3.s37
  prebuild: xncp-led_3-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'D:\SiliconLabs\v4'
  postbuild: xncp-led_3-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'D:\SiliconLabs\v4'
  ILINK.IlinkOutputFile: xncp-led_3.out
  ILINK.IlinkConfigDefines: SERIAL_UART_BTL=1; SIMEEPROM_SIZE=36864; PSSTORE_SIZE=0; LONGTOKEN_SIZE=0; HEADER_SIZE=256
  ILINK.IlinkIcfFile: ..\..\..\..\..\SiliconLabs\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\base\hal\micro\cortexm3\em35x\em3588\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/binding-table-library-cortexm3-iar-em3588-em3xx/: binding-table-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/cbke-163k1-stub-library-cortexm3-iar-em3588-em3xx/: cbke-163k1-stub-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/cbke-283k1-stub-library-cortexm3-iar-em3588-em3xx/: cbke-283k1-stub-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/cbke-library-dsa-sign-stub-cortexm3-iar-em3588-em3xx/: cbke-library-dsa-sign-stub.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-em3588-em3xx/: cbke-library-dsa-verify-283k1-stub.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/cbke-library-dsa-verify-stub-cortexm3-iar-em3588-em3xx/: cbke-library-dsa-verify-stub.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/cbke-stub-library-cortexm3-iar-em3588-em3xx/: cbke-stub-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/debug-basic-library-cortexm3-iar-em3588-em3xx/: debug-basic-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/debug-extended-library-cortexm3-iar-em3588-em3xx/: debug-extended-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/em260-uart-util-library-cortexm3-iar-em3588-em3xx/: em260-uart-util-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/em260-xncp-library-cortexm3-iar-em3588-em3xx/: em260-xncp-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/end-device-bind-library-cortexm3-iar-em3588-em3xx/: end-device-bind-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/gp-library-cortexm3-iar-em3588-em3xx/: gp-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/hal-library-cortexm3-iar-em3588-em3xx/: hal-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/install-code-library-stub-cortexm3-iar-em3588-em3xx/: install-code-library-stub.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/mfglib-library-cortexm3-iar-em3588-em3xx/: mfglib-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/multi-network-stub-library-cortexm3-iar-em3588-em3xx/: multi-network-stub-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/ncp-ash-buffers-rts-cts-library-cortexm3-iar-em3588-em3xx/: ncp-ash-buffers-rts-cts-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/ncp-binding-library-cortexm3-iar-em3588-em3xx/: ncp-binding-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/ncp-cbke-library-cortexm3-iar-em3588-em3xx/: ncp-cbke-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/ncp-gp-library-cortexm3-iar-em3588-em3xx/: ncp-gp-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/ncp-mfglib-library-cortexm3-iar-em3588-em3xx/: ncp-mfglib-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/ncp-pro-library-cortexm3-iar-em3588-em3xx/: ncp-pro-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/ncp-security-library-cortexm3-iar-em3588-em3xx/: ncp-security-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/ncp-source-route-library-cortexm3-iar-em3588-em3xx/: ncp-source-route-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/ncp-zll-library-cortexm3-iar-em3588-em3xx/: ncp-zll-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/packet-validate-library-cortexm3-iar-em3588-em3xx/: packet-validate-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/security-library-link-keys-cortexm3-iar-em3588-em3xx/: security-library-link-keys.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/sim-eeprom2-1to2-upgrade-stub-library-cortexm3-iar-em3588-em3xx/: sim-eeprom2-1to2-upgrade-stub-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/sim-eeprom2-library-cortexm3-iar-em3588-em3xx/: sim-eeprom2-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/source-route-library-cortexm3-iar-em3588-em3xx/: source-route-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/zigbee-pro-stack-cortexm3-iar-em3588-em3xx/: zigbee-pro-stack.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/zigbee-r22-support-stub-library-cortexm3-iar-em3588-em3xx/: zigbee-r22-support-stub-library.a
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/build/zll-stub-library-cortexm3-iar-em3588-em3xx/: zll-stub-library.a
  group adc
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/plugin/adc/: adc-em3xx.c
  group antenna-stub
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/plugin/antenna-stub/: antenna-stub.c
  group button-stub
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/micro/generic/: button-stub.c
  group ccm-encryption
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/stack/framework/: ccm-star.c
  group coexistence-stub
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/radio/rail_lib/plugin/coexistence/protocol/ieee802154/: coexistence-802154.c coulomb-counter-802154.c
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/radio/rail_lib/plugin/coexistence/hal/em3xx/: coexistence-hal.c
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/radio/rail_lib/plugin/coexistence/common/: coexistence.c
  group debug-channel
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/plugin/debug-jtag/: debug-jtag-em3xx.c
  group diagnostic-stub
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/micro/generic/: diagnostic-stub.c
  group ember-minimal-printf
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/plugin/serial/: ember-printf.c
  group ext-device
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/micro/cortexm3/: ext-device.c
  group hal-library
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/Device/SiliconLabs/em358x/Source/IAR/: irqToIsrTrampolines_em358x.s
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/micro/cortexm3/: assert-crash-handlers.c cstartup-common.c faults.s79 isr-stubs.s79 mfg-token.c micro-common.c micro.c mpu.c sleep.c token.c uart.c
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/micro/cortexm3/usb/cdc/: callbacks.c descriptors.c
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c em_usbtimer.c
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
  group led
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/micro/cortexm3/: led.c
  group ncp-uart
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/app/em260/: em260-common.c serial-interface-uart.c
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/stack/config/: ember-configuration.c
  group secure-ezsp-stub
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/app/util/ezsp/: secure-ezsp-stub.c
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/app/em260/: command-handlers-secure-ezsp-stub.c
  group serial
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/plugin/serial/: serial.c
  group sim-eeprom2
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/plugin/sim-eeprom2/: sim-eeprom2.c
  group strong-random
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/protocol/zigbee/stack/framework/: strong-random-api.c
  group Generated
    ./: ncp-bookkeeping.c ncp-events.c ezsp-command-handler.c ncp-callback-stubs.c ncp-callbacks.c
  group Additional
    ./: xncp-led-implementation.c ezsp-command-handler.c
    ../../../../../SiliconLabs/v4/developer/sdks/gecko_sdk_suite/v2.7/platform/base/hal/micro/cortexm3/: bootloader-interface.c bootloader-interface-standalone.c
